# Keil uVision project Dalpu6_FP.uvprojx, settings and files
target Dalpu6_FP_2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Dalpu6_FP +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --wchar32
  c include: ..\Inc;..\src;..\src\SHA256;..\src\ECC;..\src\AES;..\src\TRNG;..\src\mbedTLS;..\src\mbedTLS\include;..\src\mbedTLS\library;..\src\sdcp;..\src\FingerPrint
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\Objects\Dalpu6_FP.sct
  group Application/Usr
    ../src/: main.c
  group Driver
    ../Driver/: CMSDK_driver.c retarget.c spi_interface.c uart_stdout.c i2c_interface.c
    ./: flash_data.txt
  group FingerPrint
    ../src/FingerPrint/: cb_api.c fingerPrint.c libbarley.c
    ../src/FingerPrint/lib/: libbarley_sdk.a
  group AES
    ../src/AES/: d4_aes_test.c aes_test.c aes128e.c aes128gcm.c aes_t.c
  group mbedTLS
    ../src/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../src/mbedTLS/: hardware_rng.c
  group SDCP
    ../src/sdcp/: client.c helpers.c sdcp.c test_function.c testkeys.c
  group TRNG
    ../src/sdcp/: test_ecdsa.c
    ../src/TRNG/: CM3_TRNG.c
  group SHA256
    ../src/SHA256/: SHA256_SW.c SHA256_t.c
  group ECC
    ../src/ECC/: ec_elgamal.c ecdh_t.c ecdsa_t.c pkcc_module.c pkcc_module_vector_test.c rsa_t.c
  group DMA
    ../src/DMA/: CM3_dma.c
  group IRQ
    ../src/IRQ/: irq_test.c interrupt.c
  group I2C
    ../src/I2C/: i2c_test.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
